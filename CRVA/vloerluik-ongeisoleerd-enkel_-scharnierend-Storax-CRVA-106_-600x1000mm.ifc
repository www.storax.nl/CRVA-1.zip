Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 05f0b62e-c9f7-4dff-95be-7da6d937ce60.ifc
Time: 2026-08-11T14:36:38
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, scharnierend Storax - CRVA 106, 600x1000mm
In: Bouwlaag
Material: aluminium
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAALtp4tEDAAAA_uoCAAV2SgAA2FMBAInDAADb7AIA2uwCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAALtp4tEDAAAA_uoCAAV2SgAA2FMBAInDAADb7AIA2uwCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAA)); STABU2: 43.31.10; dagmaatlengte: 600 mm; lengte: 1111 mm; NAA.K.T: samengesteld_product_kozijn; Rc-waarde: 0 m²·k/w; breedte: 1085 mm; gewicht per st: 14 kg/st; serie: CRVA; afsluitbaar: True; hoogte: 69,5 mm; merk: Storax; breuklast: A15; type: 106; dagmaatbreedte: 1000 mm; omranding: aluminium; luik: aluminium
