Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 5f8c8bb4-0d86-4112-937a-e7b270b5e614.ifc
Time: 2026-08-11T14:37:06
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, scharnierend Storax - CRVA 108, 800x1000mm
In: Bouwlaag
Material: aluminium
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAALuL5dEDAAAA_uoCAAV2SgAA2FMBAInDAADb7AIAOOsCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAALuL5dEDAAAA_uoCAAV2SgAA2FMBAInDAADb7AIAOOsCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAA)); STABU2: 43.31.10; dagmaatlengte: 800 mm; lengte: 1111 mm; NAA.K.T: samengesteld_product_kozijn; Rc-waarde: 0 m²·k/w; breedte: 1085 mm; gewicht per st: 17 kg/st; serie: CRVA; afsluitbaar: True; hoogte: 69,5 mm; merk: Storax; breuklast: A15; type: 108; dagmaatbreedte: 1000 mm; omranding: aluminium; luik: aluminium
