Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: d3fbcfce-fb84-4fb9-ac88-750ca10a756b.ifc
Time: 2026-08-11T14:35:37
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, scharnierend Storax - CRVA 88, 800x800mm
In: Bouwlaag
Material: aluminium
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAALt45dEDAAAA_uoCAAV2SgAA2FMBAInDAADb7AIAy-sCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAALt45dEDAAAA_uoCAAV2SgAA2FMBAInDAADb7AIAy-sCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAA)); STABU2: 43.31.10; dagmaatlengte: 800 mm; lengte: 911 mm; NAA.K.T: samengesteld_product_kozijn; Rc-waarde: 0 m²·k/w; breedte: 885 mm; gewicht per st: 15 kg/st; serie: CRVA; afsluitbaar: True; hoogte: 69,5 mm; merk: Storax; breuklast: A15; type: 88; dagmaatbreedte: 800 mm; omranding: aluminium; luik: aluminium
