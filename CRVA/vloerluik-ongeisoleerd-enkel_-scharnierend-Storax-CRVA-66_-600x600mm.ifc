Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: c785edec-bb65-4ed5-94b3-7974149c2b90.ifc
Time: 2026-08-11T14:34:26
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, scharnierend Storax - CRVA 66, 600x600mm
In: Bouwlaag
Material: aluminium
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAALs95NEDAAAA_uoCAAV2SgAA2FMBAInDAADb7AIAjuoCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAALs95NEDAAAA_uoCAAV2SgAA2FMBAInDAADb7AIAjuoCAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAA)); STABU2: 43.31.10; dagmaatlengte: 600 mm; lengte: 711 mm; NAA.K.T: samengesteld_product_kozijn; Rc-waarde: 0 m²·k/w; breedte: 685 mm; gewicht per st: 10 kg/st; serie: CRVA; afsluitbaar: True; hoogte: 69,5 mm; merk: Storax; breuklast: A15; type: 66; dagmaatbreedte: 600 mm; omranding: aluminium; luik: aluminium
